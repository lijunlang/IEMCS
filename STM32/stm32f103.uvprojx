# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\EDP;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\user;.\NET\device\inc;.\NET\protocol\inc;.\core\STM32F1xx_HAL_Driver\Inc
  asm include: .\core\STM32F1xx_HAL_Driver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
    ./core/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ./hardware/src/: led.c delay.c usart.c iwdg.c info.c selfcheck.c hwtimer.c myiic.c DHT12.c at24c02.c i2c.c pm2.5.c HC-SR501.c adc.c adc_sensor.c ctrl.c
  group user
    ./user/: main.c
  group EDP
    ./EDP/: EdpKit.c cJSON.c
  group net_protocol
    ./NET/protocol/src/: fault.c onenet.c
  group net_device
    ./NET/device/src/: net_device.c net_io.c
  group Readme
    ./Readme/: 01.功能说明.txt 02.引脚接线.txt
